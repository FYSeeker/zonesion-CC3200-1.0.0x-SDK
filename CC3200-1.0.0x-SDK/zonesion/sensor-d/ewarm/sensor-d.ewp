# IAR project sensor-d.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USER_INPUT_ENABLE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../example/common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../; ../src; ../../common/dev
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sensor-d.bin
  ILINK.IlinkOutputFile: sensor-d.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: readme.txt
  group common
    ../../common/: at-uart.c at.c main.c zxbee-inf.c zxbee-sys-command.c zxbee.c
    ../../../example/common/: startup_ewarm.c
  group driver
    ../../../driverlib/: gpio.c udma.c
    ../../../example/common/: gpio_if.c uart_if.c udma_if.c
    ../../common/dev/: led.c pinmux.c relay.c systick_if.c ucfg.c
  group sensor
    ../src/: iic.c iic2.c oled.c sensor.c UserAt.c zlg7290.c
